# Keil uVision project GD32C103V_EVAL.uvproj, settings and files
target GD32C103V_EVAL (ARM-ADS)
  device: GD32C103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: GD32C10X
  c include: ..\..\..\..\GD32C10x_Firmware_Library\CMSIS\GD\GD32C10x\Include;..\..\..\..\GD32C10x_Firmware_Library\CMSIS;..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_standard_peripheral\Include;..\..\..\Utilities;..\;..\Soft_Drive;..\..\..\Utilities\LCD_Commom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32c10x_it.c systick.c
  group CMSIS
    ../../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group GD32C10x_Peripherals
    ../../../../GD32C10x_Firmware_Library/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group GD32C10x_EVAL
    ../../../Utilities/: gd32c103v_eval.c gd32c103v_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group Soft_Drive
    ../Soft_Drive/: rtc.c
  group Startup
    ../../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group Doc
    ../: readme.txt
