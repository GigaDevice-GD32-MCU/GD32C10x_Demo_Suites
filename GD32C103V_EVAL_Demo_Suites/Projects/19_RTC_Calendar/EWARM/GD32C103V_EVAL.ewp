# IAR project GD32C103V_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32C103xB GD GD32C103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: GD32C10X
  ICCARM.CCIncludePath2: ..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_standard_peripheral\Include; ..\..\..\..\GD32C10x_Firmware_Library\CMSIS\GD\GD32C10x\Include; ..; ..\..\..\Utilities; ..\Soft_Drive; ..\..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32c10x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Doc
    ../: readme.txt
  group GD32C10x_EVAL
    ../../../Utilities/: gd32c103v_eval.c gd32c103v_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group GD32C10x_Peripherals
    ../../../../GD32C10x_Firmware_Library/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: rtc.c
  group Startup
    ../../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/IAR/: startup_gd32c10x.s
