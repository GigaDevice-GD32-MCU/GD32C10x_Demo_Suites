# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32C103xB GD GD32C103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32C10X
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities; ..\..\..\..\GD32C10x_Firmware_Library\CMSIS\GD\GD32C10x\Include; ..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_standard_peripheral\Include; ..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_usbfs_library\driver\Include; ..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_usbfs_library\host\class\hid\Include; ..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_usbfs_library\host\core\Include; ..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_usbfs_library\ustd\class\hid; ..\..\..\..\GD32C10x_Firmware_Library\GD32C10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32c10x_it.c gd32c10x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Doc
    ../: readme.txt
  group GD32C10x_EVAL
    ../../../Utilities/: gd32c103c_start.c
  group GD32C10x_Peripherals
    ../../../../GD32C10x_Firmware_Library/GD32C10x_standard_peripheral/Source/: gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c
  group Startup
    ../../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/IAR/: startup_gd32c10x.s
  group USB_Class
    ../../../../GD32C10x_Firmware_Library/GD32C10x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Drivers
    ../../../../GD32C10x_Firmware_Library/GD32C10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../GD32C10x_Firmware_Library/GD32C10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
